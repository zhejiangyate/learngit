# Keil uVision project Project.uvproj, settings and files
target 洗车机器人控制板 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Driver +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe  --bin --output .\Output\Driver.bin .\Output\Driver.axf
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c misc: --cpp
  c include: .\;.\..\Libraries\CMSIS\CM3\CoreSupport;.\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\inc;.\..\ros_lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./src/: hardware_init.c main.c stm32f10x_it.c key.c led.c global.c io_config.c uart.c adc.c voltage_sensor.c current_sensor.c motor_driver.c head_driver.c head_sensor.c timer.c rtk_packge.c IMU.c
  group StdPeriph_Driver
    ./../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_usart.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dac.c stm32f10x_tim.c stm32f10x_flash.c
  group CMSIS
    ./../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK_start_code
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group roslib
    ../ros_lib/: duration.cpp time.cpp
  group math
    ../Math/: mv_math.c fast_math.c
